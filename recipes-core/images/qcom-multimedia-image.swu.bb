SWUPDATE_IMAGE = "qcom-multimedia-image"

require qcom-imdt-swu.inc
