SWUPDATE_IMAGE = "qcom-multimedia-proprietary-image"

require qcom-imdt-swu.inc
