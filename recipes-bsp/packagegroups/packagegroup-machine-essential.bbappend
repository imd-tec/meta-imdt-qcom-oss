PACKAGES:append = "\
    packagegroup-machine-essential-qcom-qcs8550-soc \
"